Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-10-18T16:12:32+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Alternativ-UI 23.0.11.19

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 0 m

# IfcFlowTerminal: SAFE MINI W-R - graphitegrey:SAFE MINI W-R - 280 lm - Einzelbatterie, SAFE MINI W-R - graphitegrey:SAFE MINI W-R - 280 lm - Einzelbatterie:2487287
In: Default
Type - Material: RAL 7024
Type - Pset_ElementShading - Color: white
Pset_DistributionFlowElementCommon - Reference: SAFE MINI W-R - 280 lm - Einzelbatterie; sets with these values: 2
